# IAR project FarmMotor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VC ST STM32F103VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\user; ..\lib\inc; ..\cmiss; ..\startup; ..\sys; ..\app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FarmMotor.srec
  ILINK.IlinkOutputFile: MotorControl.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../app/: app.c app_conf.h bsp_adc.c bsp_adc.h bsp_can1.c bsp_can1.h bsp_exti.c bsp_exti.h bsp_inputCapture.c bsp_inputCapture.h bsp_timer.c bsp_timer.h bsp_uart1.c bsp_uart1.h bsp_uart4.c bsp_uart4.h crc16_modbus.c crc16_modbus.h io_output.c io_output.h
  group CMISS
    ../cmiss/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group LIB/inc
    ../lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group LIB/src
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ../sys/: delay.c delay.h
  group USER
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
